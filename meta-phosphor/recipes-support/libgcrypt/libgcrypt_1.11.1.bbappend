EXTRA_OECONF:append:class-native = " LIBS=-lpthread"
